# Keil uVision project stm32f10x.uvprojx, settings and files
target stm32f10x (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f10x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\user;..\delay;..\led;..\usart;..\hv57708;..\ds3231;..\buzzer;..\i2c_soft;..\neon;..\timer;..\ws2812b;..\key;..\..\..\Libraries\MultiButton
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_exti.c
  group CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group startup
    ../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group doc
    ../: readme.md
  group user
    ../user/: main.c stm32f10x_it.c display.c at_cmd.c nixie_misc.c
  group usart
    ../usart/: usart.c
  group led
    ../led/: led.c
  group delay
    ../delay/: delay.c
  group hv57708
    ../hv57708/: hv57708.c
  group ds3231
    ../ds3231/: ds3231.c
  group buzzer
    ../buzzer/: buzzer.c
  group i2c_soft
    ../i2c_soft/: i2c_soft.c
  group neon
    ../neon/: neon.c
  group timer
    ../timer/: timer.c
  group ws2812b
    ../ws2812b/: ws2812b.c
  group key
    ../key/: key.c
  group multi_button
    ../../../Libraries/MultiButton/: multi_button.c
